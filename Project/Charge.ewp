# IAR project Charge.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 2
  General.GenDataModel: 2
  General.GenStackSize: 0x400
  General.GenHeapSize: 0x320
  ICCSTM8.CCDefines: USE_STM8L1528_EVAL; STM8L05X_HD_VL
  ICCSTM8.CCIncludePath2: ..\Code\1 System; ..\Code\2 Task; ..\Code\3 App; ..\Code\4 Bsp; ..\Code\5 Libraries\STM8L15x_StdPeriph_Driver\inc; ..\Code\6 Config; ..\Code\7 Middleware\cJSON; ..\Code\7 Middleware\CRC16
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Charge.hex
  ILINK.IlinkOutputFile: Charge.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group App
    ../Code/3 App/: app_clock.c app_comm_g510.c app_comm_pc.c app_common.c config.h
  group Bsp
    ../Code/4 Bsp/: bsp_adc.c bsp_common.c bsp_gpio.c bsp_gprs.c bsp_iwdg.c bsp_led.c bsp_mem.c bsp_rcc.c bsp_task.c bsp_tim.c bsp_uart.c bsp_var.c bsp_ymodem.c
  group Config
    ../Code/6 Config/: global.h
  group Lib
    ../Code/5 Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group MiddleWare/CRC
    ../Code/7 Middleware/CRC16/: crc16.c
  group System
    ../Code/1 System/: main.c stm8l15x_it.c
  group Task
    ../Code/2 Task/: 1 task_safeguard.c 2 task_control.c 3 task_mem_read.c 4 task_mem_write.c 5 task_measure.c 6 task_communicate.c 7 task_net_connect.c 8 task_interaction.c task_common.c
